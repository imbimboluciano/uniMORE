#include<stdbool.h>
#include<stdio.h>
#include<ctype.h>


bool inverti_case(const char* nomefilein, const char* nomefileout) {
	FILE* in = fopen(nomefilein, "r");
	if (in == NULL)	return false;
	FILE* out = fopen(nomefileout, "w");
	if (out == NULL) return false;
	int c = 0;
	int p = 0;
	char s;
	while (1) {
		int c = fgetc(in);
		if (c == EOF) break;
		s = c;
		if (isalpha(s) != 0) {
			if (islower(s) != 0) {
				p = fputc(toupper(s), out);
			}
			else if (isupper(s) != 0) {
				p = fputc(tolower(s), out);
			}
		}
		else {
			p = fputc(s, out);
		}
		
	}
	fclose(in);
	fclose(out);
	return true;
}
